inherit setuptools
require python-cycler.inc

inherit setuptools3
require python-cycler.inc

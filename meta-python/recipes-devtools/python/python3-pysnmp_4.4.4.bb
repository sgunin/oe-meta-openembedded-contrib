require python-pysnmp.inc
inherit setuptools

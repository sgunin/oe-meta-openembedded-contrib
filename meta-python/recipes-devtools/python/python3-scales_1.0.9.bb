inherit setuptools3
require python-scales.inc

RDEPENDS_${PN} += "\
    python3-six \
"

DEPENDS_${PN} += "\
    python3-setuptools \
"

